SUMMARY = "hello world"
LICENSE = "CLOSED"

do_fun() {
	bbplain first
	fn
}

fn:prepend() {
	bbplain second
}

fn:append() {
	bbplain fourth
}

fn() {
	bbplain third
}
