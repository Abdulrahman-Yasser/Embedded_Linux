SUMMARY = "hello python"
LICENSE = "CLOSED"

SRC_URI = "file://"
