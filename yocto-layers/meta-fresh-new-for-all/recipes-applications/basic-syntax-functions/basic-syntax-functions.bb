SUMMARY = "hello world"
LICENSE = "CLOSED"

fun() { 
	bbplain first
	fn
	bbplain sixth
}
fn::prepend() {
	bbplain second
}

fn:append() {
	bbplain fourth
	bbplain fifth
}


fn() {
	bbplain third
}
